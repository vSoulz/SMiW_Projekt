# Repository vSoulz/SMiW_Projekt

## EAGLE design Hardware/PDF/Adafruit NeoPixel 8 Stick.brd

Parts:
C1, C2, C3, C4, C5, C6, C7: C-USC0805K; C0805K
CN1, CN2: 1X4SMT; 1X4-SMT
FID1, FID3: FIDUCIAL""; FIDUCIAL_1MM
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8: WS2812B5050; WS2812B
R1: 470 OHM,; _0805MP
U$2, U$3: MOUNTINGHOLE2.0; MOUNTINGHOLE_2.0_PLATED

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, CN1.3, CN2.2, LED1.1-VDD (VDD), LED2.1-VDD (VDD), LED3.1-VDD (VDD), LED4.1-VDD (VDD), LED5.1-VDD (VDD), LED6.1-VDD (VDD), LED7.1-VDD (VDD), LED8.1-VDD (VDD)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, CN1.1, CN1.4, CN2.1, CN2.4, LED1.3-GND (GND), LED2.3-GND (GND), LED3.3-GND (GND), LED4.3-GND (GND), LED5.3-GND (GND), LED6.3-GND (GND), LED7.3-GND (GND), LED8.3-GND (GND)
unnamed: LED1.2-DOUT (DO), LED2.4-DIN (DI)
unnamed: LED2.2-DOUT (DO), LED3.4-DIN (DI)
unnamed: LED3.2-DOUT (DO), LED4.4-DIN (DI)
unnamed: LED4.2-DOUT (DO), LED5.4-DIN (DI)
unnamed: LED5.2-DOUT (DO), LED6.4-DIN (DI)
unnamed: LED6.2-DOUT (DO), LED7.4-DIN (DI)
unnamed: LED7.2-DOUT (DO), LED8.4-DIN (DI)
unnamed: CN2.3, R1.1
unnamed: CN1.2, LED8.2-DOUT (DO)
unnamed: LED1.4-DIN (DI), R1.2

Board: 2 copper layers, 50.8 x 10.2 mm, 24 parts (3 on the bottom side), 12 nets.

Other parts of the board:
U$1: ADAFRUIT_TEXT_20MM
U$4: ADAFRUIT_2.5MM

## EAGLE design Hardware/PDF/Project.brd

Parts:
ADAFRUIT_NEOPIXEL_8_STICK: MA04-1
C3, C4, C5, C6, C7, C8: 100nF; C025-024X044
IC2: MEGA8-P; DIL28-3
KANDA: ML10
L1: 10mH; A26GFC
R1: 10K; R0805
R2, R3: 4,7K; R0805
U$1: DISPLAY-OLED-128X64-I2C
U$2: ULTRASONIC-HC-SR04#V
X1: USB TYPE-B; KUSBVX-BS1N

Connections:
5V: ADAFRUIT_NEOPIXEL_8_STICK.2, C3.1, C4.1, C5.1, C7.1, IC2.7 (VCC), L1.1, R1.2, R2.2, R3.2, U$1.2 (VCC), U$2.1 (VCC), X1.1
ECHO: IC2.2 (PD0(RXD)), U$2.3 (ECHO)
GND: ADAFRUIT_NEOPIXEL_8_STICK.1, ADAFRUIT_NEOPIXEL_8_STICK.4, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, IC2.8 (GND), IC2.22 (GND), U$1.1 (GND), U$2.4 (GND), X1.4
MISO: IC2.18 (PB4(MISO)), KANDA.9
MOSI: IC2.17 (PB3(MOSI/OC2)), KANDA.1
unnamed: C8.1, IC2.20 (AVCC), L1.2
unnamed: C6.1, IC2.21 (AREF)
PIXELSTICK: ADAFRUIT_NEOPIXEL_8_STICK.3, IC2.16 (PB2(SS/OC1B))
RESET: IC2.1 (PC6(/RESET)), KANDA.5, R1.1
SCK: IC2.19 (PB5(SCK)), KANDA.7
SCL: IC2.28 (PC5(ADC5/SCL)), R3.1, U$1.3 (SCL)
SDA: IC2.27 (PC4(ADC4/SDA)), R2.1, U$1.4 (SDA)
TRIG: IC2.15 (PB1(OC1A)), U$2.2 (TRIG)

Board: 2 copper layers, 100.0 x 80.0 mm, 16 parts (0 on the bottom side), 13 nets.

## Commit log

2018-09-12 .
    .

Notices in the files:
parts and their libraries:
microbuilder: This work is placed in the public domain, and may be freely used for commercial and non-commercial work with the following conditions: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
diy-modules: Released under the Creative Commons Attribution 4.0 International License: http://creativecommons.org/licenses/by/4.0
